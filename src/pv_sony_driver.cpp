#include "pv_sony_driver.h"

#include <stdio.h>
#include <string.h>

#include "pv_fdd.h"

namespace {

static_assert(PV_FDD_DRIVE_COUNT == 2,
              "embedded Sony driver must be regenerated for a new drive count");

constexpr size_t kSonyDriverOffset = 0x17D30u;
// The large-screen initialization stub starts at 0x17F20.
constexpr size_t kDriverCapacity = 0x17F20u - kSonyDriverOffset;
constexpr uint8_t kSonyDriverSignature[] = {
    0x4F, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
    0x00, 0x6E, 0x03, 0x3A, 0x01, 0xE2, 0x02, 0xEC,
    0x00, 0x18, 0x05, '.', 'S', 'o', 'n', 'y',
};

// Assembled from pv_sony_driver.S. Keep the assembly source as the readable
// authority; this fixed payload avoids generating invariant code at runtime.
constexpr uint8_t kPvSonyDriver[] = {
    0x6f, 0x00, 0x00, 0x1e, 0x00, 0x00, 0x00, 0x00, 0x00, 0x18, 0x00, 0x6e,
    0x00, 0x7a, 0x00, 0xa6, 0x00, 0xb2, 0x05, 0x2e, 0x53, 0x6f, 0x6e, 0x79,
    0x2f, 0x08, 0x2f, 0x09, 0x70, 0x52, 0xa7, 0x1e, 0x24, 0x48, 0x22, 0x5f,
    0x20, 0x5f, 0x20, 0x0a, 0x67, 0x00, 0x00, 0x40, 0x13, 0xfc, 0x00, 0x00,
    0x00, 0x00, 0x00, 0x00, 0x4a, 0x40, 0x66, 0x00, 0x00, 0x30, 0x2f, 0x08,
    0x2f, 0x09, 0x41, 0xea, 0x00, 0x3c, 0x43, 0xfa, 0x00, 0x94, 0x21, 0x49,
    0x00, 0x06, 0xa0, 0x58, 0x22, 0x5f, 0x20, 0x5f, 0x20, 0x3c, 0x00, 0x01,
    0xff, 0xfb, 0x41, 0xea, 0x00, 0x06, 0xa0, 0x4e, 0x20, 0x3c, 0x00, 0x02,
    0xff, 0xfb, 0x41, 0xea, 0x00, 0x24, 0xa0, 0x4e, 0x4e, 0x75, 0x70, 0xe9,
    0x4e, 0x75, 0x13, 0xfc, 0x00, 0x01, 0x00, 0x00, 0x00, 0x00, 0x60, 0x00,
    0x00, 0x3e, 0x13, 0xfc, 0x00, 0x02, 0x00, 0x00, 0x00, 0x00, 0x0c, 0x68,
    0x00, 0x41, 0x00, 0x1a, 0x66, 0x00, 0x00, 0x2c, 0x4a, 0x40, 0x6f, 0x00,
    0x00, 0x26, 0x2f, 0x08, 0x2f, 0x09, 0x30, 0x7c, 0x00, 0x07, 0xa0, 0x2f,
    0x22, 0x5f, 0x20, 0x5f, 0x70, 0x00, 0x60, 0x00, 0x00, 0x12, 0x13, 0xfc,
    0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x70, 0xe8,
    0x4e, 0x75, 0x32, 0x28, 0x00, 0x06, 0x08, 0x01, 0x00, 0x09, 0x67, 0x00,
    0x00, 0x08, 0x31, 0x40, 0x00, 0x10, 0x4e, 0x75, 0x4a, 0x40, 0x6f, 0x00,
    0x00, 0x06, 0x70, 0x00, 0x4e, 0x75, 0x2f, 0x38, 0x08, 0xfc, 0x4e, 0x75,
    0x4e, 0x75,
};

static_assert(sizeof(kPvSonyDriver) <= kDriverCapacity,
              "PV Sony driver no longer fits in the ROM resource");

constexpr size_t kPvAddressOffsets[] = {48, 114, 126, 170};

constexpr bool addressFieldsAreZero() {
    for (size_t offset : kPvAddressOffsets) {
        for (size_t byte = 0; byte < sizeof(uint32_t); ++byte) {
            if (kPvSonyDriver[offset + byte] != 0) {
                return false;
            }
        }
    }
    return true;
}

static_assert(addressFieldsAreZero(),
              "PV address offsets do not point to zero placeholders");

void writeBigEndian32(uint8_t *destination, uint32_t value) {
    destination[0] = (uint8_t)(value >> 24);
    destination[1] = (uint8_t)(value >> 16);
    destination[2] = (uint8_t)(value >> 8);
    destination[3] = (uint8_t)value;
}

} // namespace

bool pvSonyPatchRom(uint8_t *rom, size_t romSize) {
    if (!rom || romSize < kSonyDriverOffset + kDriverCapacity) {
        printf("FDD ROM PATCH: ROM buffer is too small\n");
        return false;
    }
    if (memcmp(rom + kSonyDriverOffset,
               kSonyDriverSignature,
               sizeof(kSonyDriverSignature)) != 0) {
        printf("FDD ROM PATCH: .Sony resource signature mismatch at 0x%05X\n",
               (unsigned)kSonyDriverOffset);
        return false;
    }

    memcpy(rom + kSonyDriverOffset, kPvSonyDriver, sizeof(kPvSonyDriver));
    for (size_t offset : kPvAddressOffsets) {
        writeBigEndian32(rom + kSonyDriverOffset + offset, PV_FDD_GUEST_ADDR);
    }
    printf("FDD ROM PATCH: installed original PV driver (%u bytes at 0x%05X)\n",
           (unsigned)sizeof(kPvSonyDriver), (unsigned)kSonyDriverOffset);
    return true;
}
